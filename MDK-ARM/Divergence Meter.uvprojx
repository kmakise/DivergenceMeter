# Keil uVision project Divergence Meter.uvprojx, settings and files
target Divergence Meter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Divergence Meter +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Application\Amadeus\inc;..\Application\Hardware\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Application/Amadeus/src
    ../Application/Amadeus/src/: AmadeusMain.c NixieApp.c
  group Application/Amadeus/inc
    ../Application/Amadeus/inc/: AmadeusMain.h NixieApp.h
  group Application/Hardware/src
    ../Application/Hardware/src/: DS3231.c HighVoltage.c KeyBoard.c NixieTube.c oled.c
  group Application/Hardware/inc
    ../Application/Hardware/inc/: bmp.h DS3231.h HighVoltage.h KeyBoard.h NixieTube.h oled.h oledfont.h
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
  group Application/User
    ../Core/Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_dma.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
